FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
RRECOMMENDS_${PN}_remove = "wpa-supplicant-passphrase wpa-supplicant-cli"
